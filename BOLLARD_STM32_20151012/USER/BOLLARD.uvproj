# Keil uVision project BOLLARD.uvproj, settings and files
target BOLLARD (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: BOLLARD
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USER;..\STM32F10x_FWLib\inc;..\HARDWARE\MODBUS\ascii;..\HARDWARE\MODBUS\functions;..\HARDWARE\MODBUS\include;..\HARDWARE\MODBUS\rtu;..\HARDWARE\MODBUS\tcp;..\HARDWARE\PORT;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\RS485;..\HARDWARE\LED;..\HARDWARE\MALLOC;..\HARDWARE\SD;..\HARDWARE\SPI;..\FATFS;..\FATFS\exfuns;..\FATFS\src;..\HARDWARE\RTC;..\HARDWARE\TIMER;..\HARDWARE\KEY;..\HARDWARE\BEEP;..\HARDWARE\EXTI;..\HARDWARE\IIC;..\HARDWARE\24CXX
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c main.c init.c controlfunction.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    ../HARDWARE/MODBUS/ascii/: mbascii.c
    ../HARDWARE/MODBUS/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c mbfunction.c
    ../HARDWARE/MODBUS/rtu/: mbcrc.c mbrtu.c
    ../HARDWARE/MODBUS/tcp/: mbtcp.c
    ../HARDWARE/MODBUS/: mb.c
    ../HARDWARE/PORT/: portevent.c portserial.c porttimer.c port.c
    ../HARDWARE/RS485/: rs485.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/SD/: MMC_SD.C recordmanage.c
    ../HARDWARE/MALLOC/: malloc.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/24CXX/: 24cxx.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/: fattester.c
    ../FATFS/exfuns/: exfuns.c
    ../FATFS/src/option/: cc936.c
